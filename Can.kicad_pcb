# Repository KicadProyects/Can

## KiCad design Can.kicad_pcb

Parts:
C1, C3, C6, C9, C10, C11, C14: 100nf; C_1206
C2: 22uf; TantalC_SizeS_EIA-3216
C4, C5, C7, C8: 22pf; C_1206
C12, C13: 1nf; C_1206
CAN1: CONN_01X02; mstbva_2,5%2f2-g-5,08
D1, D2, D6, D7: LED; Led_1206
D3, D4: 1N4148; diode_do35
D5: 1N4001; SMA_Standard
IC1: ATMEGA328P-A; TQFP-32_7x7mm_Pitch0.8mm
ICSP1: CONN_01X06; Pin_Header_Straight_1x06
K1, K2: HK4100F
P3, P4: CONN_01X03; mstbva_2,5%2f3-g-5,08
P5: CONN_01X02; mstbva_2,5%2f2-g-5,08
P6: CONN_01X02; Pin_Header_Straight_1x02
Q1, Q2: BC808-40; sot23
R1, R6, R7, R9, R10, R11: 1k; R_1206
R2, R3, R4, R5: 10k; R_1206
R8: R; R_1206
SW1: SW_PUSH; smd_push
U1: AMS1117-RESCUE-Proyecto; SOT-223
U3: MCP2551-I/SN; SOIC-8_3.9x4.9mm_Pitch1.27mm
U4, U5: ACS712; SOIC-8_3.9x4.9mm_Pitch1.27mm
Y1, Y2: 16Mhz; crystal_hc-49s
carga1: CONN_01X02; Pin_Header_Straight_1x02

Connections:
+5V: C1.1, C2.1, C3.1, C6.1, C9.1, C10.1, C11.1, D3.1 (K), D4.1 (K), D5.2 (A), IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC1.20 (AREF), ICSP1.6, K1.2, K2.2, R1.1, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R11.2, U1.2, U1.4, U3.3 (VDD), U4.8, U5.8; also elsewhere on the board
/ACS1: IC1.24 ((PCINT9/ADC1)PC1), U4.7
/ACS2: IC1.26 ((PCINT11/ADC3)PC3), U5.7
/R1: IC1.23 ((PCINT8/ADC0)PC0), R9.2
/R2: IC1.25 ((PCINT10/ADC2)PC2), R10.2
/RX: D2.1 (K), U3.4 (RXD); also elsewhere on the board
/TX: D1.1 (K), U3.1 (TXD); also elsewhere on the board
/cs: IC1.14 ((PCINT2/OC1B/~SS~)PB2), R2.1; also elsewhere on the board
/rst: IC1.29 ((PCINT14/~RESET~)PC6), ICSP1.4, R5.1, SW1.2
/sck: IC1.17 ((PCINT5/SCK)PB5), ICSP1.1; also elsewhere on the board
/si: IC1.15 ((PCINT3/OC2A/MOSI)PB3), ICSP1.2; also elsewhere on the board
/so: IC1.16 ((PCINT4/MISO)PB4), ICSP1.3; also elsewhere on the board
/test: D7.1 (K), IC1.32 ((PCINT18/INT0)PD2)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D6.1 (K), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), ICSP1.5, P5.1, Q1.3 (C), Q2.3 (C), SW1.1, U1.1, U3.2 (VSS), U3.8 (Rs), U4.5, U5.5; also elsewhere on the board
unnamed: C4.2, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), Y1.2
unnamed: C5.2, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), Y1.1
unnamed 16: C7.2, Y2.2; also elsewhere on the board
unnamed 17: C8.2, Y2.1; also elsewhere on the board
unnamed: C12.1, U4.6
unnamed: C13.1, U5.6
unnamed: C14.1, D5.1 (K), P5.2, U1.3
unnamed: CAN1.1, R8.1, U3.7 (CANH)
unnamed: CAN1.2, U3.6 (CANL), carga1.1
unnamed: D1.2 (A), R6.1
unnamed: D2.2 (A), R7.1
unnamed: D3.2 (A), K1.5, Q1.2 (E)
unnamed: D4.2 (A), K2.5, Q2.2 (E)
unnamed: D6.2 (A), R1.2
unnamed: D7.2 (A), R11.1
unnamed 29: IC1.13 ((PCINT1/OC1A)PB1), R3.1; also elsewhere on the board
unnamed: IC1.30 ((PCINT16/RXD)PD0), P6.1
unnamed: IC1.31 ((PCINT17/TXD)PD1), P6.2
unnamed: K1.1, U4.1, U4.2
unnamed: K1.3, P3.3
unnamed: K1.4, P3.1
unnamed: K2.1, U5.1, U5.2
unnamed: K2.3, P4.3
unnamed: K2.4, P4.1
unnamed: P3.2, U4.3, U4.4
unnamed: P4.2, U5.3, U5.4
unnamed: Q1.1 (B), R9.1
unnamed: Q2.1 (B), R10.1
unnamed 42: R4.1; also elsewhere on the board
unnamed: R8.2, carga1.2

Board: 2 copper layers, 60.2 x 48.8 mm, 52 parts (22 on the bottom side), 44 nets.

Other parts of the board:
U2: MCP2515; SOIC-18_7.5x11.6mm_Pitch1.27mm

Their connections:
+5V: U2.18; also elsewhere on the board
/RX: U2.2; also elsewhere on the board
/TX: U2.1; also elsewhere on the board
/cs: U2.16; also elsewhere on the board
/sck: U2.13; also elsewhere on the board
/si: U2.14; also elsewhere on the board
/so: U2.15; also elsewhere on the board
GND: U2.9; also elsewhere on the board
unnamed 16: U2.8; also elsewhere on the board
unnamed 17: U2.7; also elsewhere on the board
unnamed 29: U2.12; also elsewhere on the board
unnamed 42: U2.17; also elsewhere on the board

## Commit log

2016-07-20 :octocat: Added .gitattributes & .gitignore files
2016-07-30 plano de masa y vcc
2016-09-14 fix islas 220v
